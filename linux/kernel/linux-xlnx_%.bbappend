FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://usb_audio_host.cfg"
